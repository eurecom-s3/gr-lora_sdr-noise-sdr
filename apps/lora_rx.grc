<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>config</value></param>
<param><key>field0</key><value>framePeriod</value></param>
<param><key>field1</key><value>nFrame</value></param>
<param><key>field2</key><value>multConst</value></param>
<param><key>field3</key><value>outRate</value></param>
<param><key>value0</key><value>200</value></param>
<param><key>value2</key><value>0.5</value></param>
<param><key>value1</key><value>1</value></param>
<param><key>value3</key><value>48000</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq</value></param>
<param><key>block_id</key><value>sweepFreq</value></param>
<param><key>function_args</key><value>False</value></param>
<param><key>function_name</key><value>work</value></param>
<param><key>value</key><value>minFreq</value></param>
<param><key>poll_rate</key><value>hz</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>lora</value></param>
<param><key>field0</key><value>bw</value></param>
<param><key>field1</key><value>sampRate</value></param>
<param><key>field2</key><value>sf</value></param>
<param><key>field3</key><value>implHead</value></param>
<param><key>field4</key><value>cr</value></param>
<param><key>field5</key><value>hasCrc</value></param>
<param><key>field6</key><value>payLen</value></param>
<param><key>value0</key><value>8000</value></param>
<param><key>value4</key><value>4</value></param>
<param><key>value5</key><value>True</value></param>
<param><key>value3</key><value>False</value></param>
<param><key>value6</key><value>16</value></param>
<param><key>value1</key><value>8000</value></param>
<param><key>value2</key><value>8</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>offset</value></param>
<param><key>block_id</key><value>sweepFreq</value></param>
<param><key>function_args</key><value>True</value></param>
<param><key>function_name</key><value>work</value></param>
<param><key>value</key><value>minOffset</value></param>
<param><key>poll_rate</key><value>hz</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>radio</value></param>
<param><key>field0</key><value></value></param>
<param><key>field2</key><value>sampRate</value></param>
<param><key>field3</key><value>gain</value></param>
<param><key>value3</key><value>76</value></param>
<param><key>value2</key><value>5000000</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0</value></param>
<param><key>dist</key><value>blocks.STROBE_UNIFORM</value></param>
<param><key>mean</key><value>config.framePeriod</value></param>
<param><key>msg</key><value>pmt.intern('')</value></param>
<param><key>std</key><value>5</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>radio.sampRate</value></param>
<param><key>taps</key><value>100</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hz</value></param>
<param><key>label</key><value>hz</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>taps</key><value>-0.128616616593872,	-0.212206590789194,	-0.180063263231421,	3.89817183251938e-17	,0.300105438719035	,0.636619772367581	,0.900316316157106,	1	,0.900316316157106,	0.636619772367581,	0.300105438719035,	3.89817183251938e-17,	-0.180063263231421,	-0.212206590789194,	-0.128616616593872</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>log</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pandas as pd
import pmt
from unidecode import unidecode


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, filename="/tmp/lora_scan.csv", freq=0, offset=0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Log HD5',   # will show up in GRC
            in_sig=None,
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.freq = freq
        self.offset = offset
        self.filename = filename

        self.message_port_register_in(pmt.string_to_symbol('pdu'))
        self.set_msg_handler(pmt.string_to_symbol('pdu'), self.insert_pdu_into_dataset)

        df = pd.DataFrame({'freq [Hz]':[0], 'offset [Hz]':[0]}) #, 'msg':[""]})
        df.to_csv(self.filename, mode='w', header=False)

    def work(self, input_items, output_items):
        return

    def insert_pdu_into_dataset(self, pdu):
        print(self.freq, self.offset, pdu)
        #asciistring = unidecode(unicode(pmt.symbol_to_string(pdu), encoding = "utf-8"))
        #asciistring = ''.join([i if ord(i) &lt; 128 else ' ' for i in pmt.symbol_to_string(pdu)])
        df = pd.DataFrame({'freq [Hz]':[self.freq], 'offset [Hz]':[self.offset]}) #, 'msg':[asciistring]})
        df.to_csv(self.filename, mode='a', header=False)     
        return

</value></param>
<param><key>filename</key><value>'/tmp/lora_scan.csv'</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>offset</key><value>offset</value></param>
</block>
<block>
<key>lora_sdr_crc_verif</key>
<param><key>id</key><value>lora_sdr_crc_verif_0</value></param>
</block>
<block>
<key>lora_sdr_data_source</key>
<param><key>id</key><value>lora_sdr_data_source_0</value></param>
<param><key>n_frames</key><value>config.nFrame</value></param>
<param><key>pay_len</key><value>lora.payLen</value></param>
</block>
<block>
<key>lora_sdr_deinterleaver</key>
<param><key>id</key><value>lora_sdr_deinterleaver_0</value></param>
<param><key>sf</key><value>lora.sf</value></param>
</block>
<block>
<key>lora_sdr_dewhitening</key>
<param><key>id</key><value>lora_sdr_dewhitening_0</value></param>
</block>
<block>
<key>lora_sdr_err_measures</key>
<param><key>id</key><value>lora_sdr_err_measures_0</value></param>
</block>
<block>
<key>lora_sdr_fft_demod</key>
<param><key>id</key><value>lora_sdr_fft_demod_0</value></param>
<param><key>bandwidth</key><value>lora.bw</value></param>
<param><key>impl_head</key><value>lora.implHead</value></param>
<param><key>is_simple</key><value>False</value></param>
<param><key>samp_rate</key><value>lora.sampRate</value></param>
<param><key>sf</key><value>lora.sf</value></param>
</block>
<block>
<key>lora_sdr_frame_sync</key>
<param><key>id</key><value>lora_sdr_frame_sync_0</value></param>
<param><key>bandwidth</key><value>lora.bw</value></param>
<param><key>impl_head</key><value>lora.implHead</value></param>
<param><key>samp_rate</key><value>lora.sampRate</value></param>
<param><key>sf</key><value>lora.sf</value></param>
</block>
<block>
<key>lora_sdr_gray_enc</key>
<param><key>id</key><value>lora_sdr_gray_enc_0</value></param>
</block>
<block>
<key>lora_sdr_hamming_dec</key>
<param><key>id</key><value>lora_sdr_hamming_dec_0</value></param>
</block>
<block>
<key>lora_sdr_header_decoder</key>
<param><key>id</key><value>lora_sdr_header_decoder_0</value></param>
<param><key>cr</key><value>lora.cr</value></param>
<param><key>has_crc</key><value>lora.hasCrc</value></param>
<param><key>impl_head</key><value>lora.implHead</value></param>
<param><key>pay_len</key><value>lora.payLen</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>maxFreq</value></param>
<param><key>label</key><value>maxFreq</value></param>
<param><key>value</key><value>400e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>maxOffset</value></param>
<param><key>label</key><value>maxOffset</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>minFreq</value></param>
<param><key>label</key><value>minFreq</value></param>
<param><key>value</key><value>400e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>minOffset</value></param>
<param><key>label</key><value>minOffset</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>1.0*lora.bw/radio.sampRate</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>stepFreq</value></param>
<param><key>label</key><value>stepFreq</value></param>
<param><key>value</key><value>200000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>stepOffset</value></param>
<param><key>label</key><value>stepOffset</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>sweepFreq</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr

class sweepFreq(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block"""
    def __init__(self, minFreq = 400e6, maxFreq = 2e9, stepFreq = 100e6, minOffset = 6e3, maxOffset = 10e3, stepOffset = 1e3):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__( self, name='Increase Frequency', in_sig=[], out_sig=[] )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.minFreq = minFreq;
        self.maxFreq = maxFreq;
        self.stepFreq = stepFreq;
        self.minOffset = minOffset;
        self.maxOffset = maxOffset;
        self.stepOffset = stepOffset;

        self.freq = self.minFreq
        self.offset = self.minOffset  

    def work(self, isOffset):
        if self.offset &lt; self.maxOffset:
            if isOffset:
                self.offset += self.stepOffset
        else:
            if not isOffset:
                self.offset = self.minOffset
                if self.freq &lt; self.maxFreq:
                    self.freq += self.stepFreq
                else:
                    self.freq = self.minFreq

        print isOffset, self.freq, self.offset

        if isOffset:
           return self.offset
        else:
           return self.freq
</value></param>
<param><key>comment</key><value>ID: incFreq</value></param>
<param><key>maxFreq</key><value>maxFreq</value></param>
<param><key>maxOffset</key><value>maxOffset</value></param>
<param><key>minFreq</key><value>minFreq</value></param>
<param><key>minOffset</key><value>minOffset</value></param>
<param><key>stepFreq</key><value>stepFreq</value></param>
<param><key>stepOffset</key><value>stepOffset</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>radio.sampRate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>radio.gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>radio.sampRate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>freq+offset</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>radio.sampRate</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_random_0</source_block_id><sink_block_id>lora_sdr_data_source_0</sink_block_id><source_key>strobe</source_key><sink_key>trigg</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_crc_verif_0</source_block_id><sink_block_id>log</sink_block_id><source_key>msg</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>lora_sdr_crc_verif_0</source_block_id><sink_block_id>lora_sdr_err_measures_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>lora_sdr_data_source_0</source_block_id><sink_block_id>lora_sdr_err_measures_0</sink_block_id><source_key>msg</source_key><sink_key>ref</sink_key></connection>
<connection><source_block_id>lora_sdr_deinterleaver_0</source_block_id><sink_block_id>lora_sdr_hamming_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_dewhitening_0</source_block_id><sink_block_id>lora_sdr_crc_verif_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_fft_demod_0</source_block_id><sink_block_id>lora_sdr_gray_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_deinterleaver_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_fft_demod_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_hamming_dec_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_header_decoder_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_fft_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_gray_enc_0</source_block_id><sink_block_id>lora_sdr_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_hamming_dec_0</source_block_id><sink_block_id>lora_sdr_header_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_deinterleaver_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_fft_demod_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_hamming_dec_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_crc_verif_0</sink_block_id><source_key>CRC</source_key><sink_key>CRC</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>CRC</source_key><sink_key>CRC</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>CRC</source_key><sink_key>crc</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>err</source_key><sink_key>err</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_crc_verif_0</sink_block_id><source_key>pay_len</source_key><sink_key>pay_len</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>pay_len</source_key><sink_key>pay_len</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>pay_len</source_key><sink_key>pay_len</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
